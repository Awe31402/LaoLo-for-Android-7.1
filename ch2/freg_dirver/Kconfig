## ch2/freg_dirver/Kconfig
```kconfig
config FREG
    tristate "Fake Register Device"
    default n
    help
    This is Fake Register Device for android system
```
